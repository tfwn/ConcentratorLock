# IAR project SRWF-6009.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103RE ST STM32F103RE
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F10X_HD
  ICCARM.PreInclude: ..\Source\USER\Common.h
  ICCARM.CCIncludePath2: ..\Source\uCOS-II\Config; ..\Source\uCOS-II\Ports; ..\Source\uCOS-II\Source; ..\Source\CMSIS; ..\Source\FWLib\inc; ..\Source\FWLib\inc\usb; ..\Source\BSP; ..\Source\USER
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: SRWF-6009-APP.bin
  postbuild: Debug\Exe\CreateBurnFile.bat
  ILINK.IlinkOutputFile: SRWF-6009.out
  ILINK.IlinkIcfFile: stm32f10x_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group BSP
    ../Source/BSP/: Bsp.c Flash.c Rtc.c SerialPort.c stm32f10x_it.c Timer.c
  group CMSIS
    ../Source/CMSIS/: core_cm3.c
    ../Source/CMSIS/startup/iar/: startup_stm32f10x_hd.s
  group FWLib
    ../Source/FWLib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_dma.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_tim.c stm32f10x_usart.c
  group FWLib/Usb
    ../Source/FWLib/src/usb/: usb_core.c usb_desc.c usb_init.c usb_int.c usb_istr.c usb_mem.c usb_prop.c usb_pwr.c usb_regs.c
  group uCOS-II
    ../Source/uCOS-II/Source/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
    ../Source/uCOS-II/Ports/: os_cpu_a.asm os_cpu_c.c os_dbg.c
  group USER
    ../Source/USER/: aes.c Common.c Database.c DataHandle.c Eeprom.c Gprs.c Led.c Main.c md5.c
